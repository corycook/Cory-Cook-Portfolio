LAB3 Circuit Simulation
Ex 3 4 3 1 2.0

V4 1 2 4V
V6 3 2 6V

R1 1 0 20
Rx 1 3 6
R6 2 0 5
R2 2 4 12
R3 4 0 4

.DC V6 6 6 1
.PRINT DC V(1,0) V(3,1) V(4,0)
